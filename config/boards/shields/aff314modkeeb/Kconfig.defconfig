## config/boards/shields/aff314modkeeb/Kconfig.defconfig
```kconfig
if SHIELD_AFF314MODKEEB

config ZMK_KEYBOARD_NAME
    dafault "AFF314MODKEEB"

endif
```
